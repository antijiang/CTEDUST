# Keil uVision project DustSensor.uvproj, settings and files
target DustSensor (ARM-ADS)
  device: M058ZBN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x07FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DustSensor +hex
  AfterMake: d:\keil\arm\armcc\bin\fromelf --bin ".\out\@L.axf" --output ".\out\@L.bin"
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\M051-LB_004_Driver\inc;..\StdDriver\inc;..\CM0\CoreSupport;..\CM0\M051Series;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group Boot
    ../CM0/CoreSupport/: core_cm0.c
    ../CM0/M051Series/: system_M051Series.c startup_M051Series.s
  group Src
    ../M051-LB_004_Driver/src/: Ascii_Table.C lcdjxldrv.c
    ./src/: main.c Flash_Simple.c SerialTransfer.c DustSensor.c
  group Lib
    ../StdDriver/src/: retarget.c
